# Keil uVision project HIKIT.uvprojx, settings and files
target W5500 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F103C8 APEXMIC
  pack: APEXMIC.APM32F1xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: W5500 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Ethernet\Internet;..\..\User\Ethernet\W5500;..\..\User\usart;..\..\User\led;..\..\User\I2C_EEPROM;..\..\User\spi;..\..\User\bsp_dht11;..\..\User\TimBase;..\..\User\include;..\..\User\include\w5500
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group APP
    ../../User/: at24c16.c device.c main.c mcu_init.c sockutil.c stm32f10x_it.c util.c dhcp.c
  group W5500
    ../../User/w5500/: md5.c socket.c SPI2.c w5500.c
software components: CMSIS:CORE 5.4.0
